# Keil uVision project opensdk.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ec_open_mcu_app +hex
  AfterMake: ecBuild.exe
  AfterMake: copy.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\ec_app;..\ec_core;..\demo;..\..\..\..\lib\RsCore
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: .\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group ec_app
    ../ec_app/: main.c ec_app_flash.c rsBlePeripheral.c RsBle.c RsGpio.c RsUart.c
  group ec_core
    ../ec_core/: ec_core.h ec_core_adc.h ec_core_ble.h ec_core_ble_central.h ec_core_ble_peripheral.h ec_core_clk.h ec_core_delay.h ec_core_flash.h ec_core_gpio.h ec_core_led.c ec_core_led.h ec_core_printf.h ec_core_pwm.h ec_core_sleep.h ec_core_timer.h ec_core_uart.h ec_core_wdg.h ec_core_key.c ec_core_key.h ec_core_i2c.c ec_core_i2c.h ec_core_spi_ssd1306_oled.c ec_core_spi_ssd1306_oled.h ec_core_wdg.c
  group ec_lib
    ../ec_lib/lib/: ble_host.lib rf.lib
    ../ec_lib/o/: adc.o central.o clock.o dma.o ec_app_task.o ec_ble.o ec_ble_central.o ec_ble_peripheral.o ec_core.o ec_core_adc.o ec_core_ble.o ec_core_ble_central.o ec_core_ble_peripheral.o ec_core_clk.o ec_core_delay.o ec_core_flash.o ec_core_gpio.o ec_core_printf.o ec_core_pwm.o ec_core_sleep.o ec_core_timer.o ec_core_uart.o flash.o fs.o gap.o gapbondmgr.o gapgattserver.o gattservapp.o gpio.o jump_table.o my_printf.o osal_simpleble.o osal_snv.o ota_app_service.o peripheral.o pwm.o pwrmgr.o sbpprofile_ota.o simpleble_main.o simpleblecentral.o simplebleperipheral.o spi.o spiflash.o timer.o uart.o watchdog.o ec_app_task2.o
  group rs_core
    ../../../../lib/RsCore/: RsProtocol.c RsServerLib.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
